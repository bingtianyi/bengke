# Keil uVision project project.uvprojx, settings and files
target STM32F103C8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARM_MATH_CM3,STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: .\Start;.\Library;.\User;.\HardWare;.\System;.\User;.\APP;.\BSP\Sensor;.\BSP\Actuator;.\BSP\Comm;.\BSP\Extern;.\DSPLIB;.\DSPLIB\Include;.\Middlewares
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.h stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HardWare
    ./HardWare/: LED.c KEY.c OLED.c OLED_Data.c OLED_Data.h
  group System
    ./System/: sys.c Task.c adcx.c MyRTC.c MyFLASH.c Store.c usart_log.c
  group App
    ./APP/: Sensor_Task.c Actuator_Task.c Comm_Task.c Extern_Task.c Action_Task.c
  group Sensor
    ./BSP/Sensor/: dht11.c BH1750.c LDR.c sw420.c IR.c HW.c TS.c ds18b20.c adxl345.c xinlv.c bmp280.c mq2.c mq7.c mq135.c body_hw.c SR04.c ccs811.c MFRC522.c gate_guard.c button4_4.c FSR402.c sht30.c hx711.c PM25.c JW01.c water.c rain.c tds.c ts_300b.c ph.c JW013.c as608.c max30102.c max30102_fir.c MPU6050.c mq4.c mq3.c ina226.c GPS.c D01.c sgp30.c ms1100.c CountSensor.c
    ./BSP/Actuator/: mlx90614.c
  group Actuator
    ./BSP/Actuator/: stepper_motor.c relay.c beep.c fan.c bump.c led_module.c jsq.c servo.c ptc.c tec.c tb6612.c led_array.c shake_motor.c
  group Comm
    ./BSP/Comm/: HC05.c NRF24L01.c Zigbee.c Lora.c IR_Remote.c wifi.c
  group Extern
    ./BSP/Extern/: ds1302.c jq6500.c JR6001.c JQ8900.c Asrpro.c
  group Middlewares
    ./Middlewares/: cJSON.c
  group DSP
    ./DSPLIB/: arm_cortexM3l_math.lib
  group Doc
    ./Doc/: Note.txt
